# Keil uVision project code.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: code
  AfterMake: fromelf --bin code.axf -o code.bin
  AfterMake: fromelf -cvf code.axf -o disasm.txt
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ../../../src/sw/uRobotDigitalController/: cm0dsasm.s Int_Handlers.h main.c Memory_Map.h retarget.c rf_global_vars.h bucket_o_functions.h bucket_o_functions.c
