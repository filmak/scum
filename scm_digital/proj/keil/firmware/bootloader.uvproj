# Keil uVision project bootloader.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.1.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: bootloader +hex
  AfterMake: fromelf --bin bootloader.axf -o code.bin
  AfterMake: fromelf -cvf bootloader.axf -o disasm.txt
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\code.sct
  group Source Group 1
    ../../../src/sw/firmware/: cm0dsasm.s main.c Memory_Map.h retarget.c
