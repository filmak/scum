# Keil uVision project std_synchronization.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: std_synchronization
  AfterMake: fromelf --bin .\Objects\std_synchronization.axf -o .\Objects\std_synchronization.bin
  AfterMake: fromelf -cvf .\Objects\std_synchronization.axf -o .\Objects\disasm.txt
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: cm0dsasm.s main.c Memory_Map.h retarget.c
